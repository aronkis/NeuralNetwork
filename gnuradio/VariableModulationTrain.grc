options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: VariableModulation
    output_language: python
    title: Variable Modulations Train
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1+0j, 1 + 0j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: 2**15
  states: {}
- name: lo_freq
  id: variable
  parameters:
    value: '2200000000'
  states: {}
- name: lo_p
  id: variable_qtgui_range
  parameters:
    gui_hint: (6, 1, 1, 1)
    label: LO Diff
    start: '-25000'
    step: '10'
    stop: '25000'
    value: '0'
  states: {}
- name: offset_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: (6, 0, 1, 1)
    start: '-3 * 10 ** 5'
    step: '1'
    stop: 2.5 * 10 **5
    value: '-10 **  5'
  states: {}
- name: offset_tx
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: pluto_ip_rx
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ip:192.168.2.1
    writeback: None
  states: {}
- name: pluto_ip_tx
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ip:192.168.3.1
    writeback: None
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    const_points: '[-3-3j, -1-3j, 1-3j, 3-3j, -3-1j, -1-1j, 1-1j, 3-1j, -3+1j, -1+1j, 1+1j, 3+1j, -3+3j, -1+3j, 1+3j, 3+3j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    type: calcdist
  states: {}
- name: qam32
  id: variable_constellation
  parameters:
    const_points: '[-5-3j, -3-3j, -1-3j, 1-3j, 3-3j, 5-3j, -5-1j, -3-1j, -1-1j, 1-1j, 3-1j, 5-1j, -5+1j, -3+1j, -1+1j, 1+1j, 3+1j, 5+1j, -5+3j, -3+3j, -1+3j, 1+3j, 3+3j, 5+3j, -3-5j, -1-5j, 1-5j, 3-5j, -3+5j, -1+5j, 1+5j, 3+5j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31]'
    type: calcdist
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    const_points: '[-1 - 1j, +1 - 1j, +1+1j, -1 + 1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: rnd_mod_fnc
  id: variable_function_probe
  parameters:
    block_id: rnd_mod
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,1,1,1)
    start: '0'
    step: '1'
    stop: '60'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10**6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,1)
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_random_uniform_source_x_1
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_random_uniform_source_x_2
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_random_uniform_source_x_3
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_random_uniform_source_x_3_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_tx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_rx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1000'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_1_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '5'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: rnd_mod_fnc
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam16
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam32
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class labeled_iq_block(gr.sync_block):
          """Appends modulation label to I/Q vector"""
          
          def __init__(self, label_var=0):
              gr.sync_block.__init__(
                  self,
                  name='Labeled IQ',
                  in_sig=[(np.complex64, 2048)],  # Input: 2048 complex samples
                  out_sig=[(np.float32, 4097)]    # Output: 4096 floats + 1 label
              )
              self.label_var = label_var
          
          def set_label_var(self, label_var):
              self.label_var = label_var
          
          def work(self, input_items, output_items):
              # Get label - handle both callable and direct value
              if callable(self.label_var):
                  label = float(self.label_var())
              else:
                  label = float(self.label_var)
              
              for i in range(len(input_items[0])):
                  iq = input_items[0][i]
                  # Interleave I/Q: [I0, Q0, I1, Q1, ...]
                  output_items[0][i][:4096:2] = iq.real
                  output_items[0][i][1:4096:2] = iq.imag
                  # Append label as last element
                  output_items[0][i][4096] = label
              return len(input_items[0])
    label_var: rnd_mod_fnc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: samp_rate * 5
    buffer_size: buff_size
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lo_freq + lo_p
    samplerate: samp_rate
    type: fc32
    uri: pluto_ip_tx
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate * 5
    bbdc: 'True'
    buffer_size: buff_size
    filter_source: '''Auto'''
    frequency: lo_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_ip_rx
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Used for sending samples through a network
  states: {}
- name: rnd_mod
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: pluto_tx_baseband
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    hwm: '1000'
    timeout: '100'
    type: float
    vlen: '4097'
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [analog_random_uniform_source_x_1, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [analog_random_uniform_source_x_2, '0', blocks_packed_to_unpacked_xx_0_1, '0']
- [analog_random_uniform_source_x_3, '0', blocks_packed_to_unpacked_xx_0_1_0, '0']
- [analog_random_uniform_source_x_3_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_keep_one_in_n_0, '0', rnd_mod, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_constellation_modulator_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_1, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_1_0, '0', digital_constellation_modulator_0_0_0_0, '0']
- [blocks_selector_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [digital_constellation_modulator_0, '0', blocks_selector_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_selector_0_0, '1']
- [digital_constellation_modulator_0_0_0, '0', blocks_selector_0_0, '2']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_selector_0_0, '3']
- [epy_block_0, '0', zeromq_pub_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
